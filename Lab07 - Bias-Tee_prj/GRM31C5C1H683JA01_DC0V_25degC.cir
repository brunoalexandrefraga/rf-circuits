*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G/68000pF/50V
* Murata P/N :GRM31C5C1H683JA01
* Property : C = 68000[pF]
* Data Generated on Jan 10, 2017
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM31C5C1H683JA01_DC0V_25degC port1 port2
C1 port1 11 6.66e-8
L2 11 12 2.88e-12
R3 12 13 3.97e-3
L4 13 14 1.61e-11
R4 13 14 2.79e-1
L5 14 15 1.83e-10
R5 14 15 1.31e-1
L6 15 16 2.89e-11
R6 15 16 6.16e-3
C7 16 17 2.14e-7
L7 16 17 7.47e-11
R7 16 17 1.68e-1
C8 17 18 8.34e-8
L8 17 18 8.56e-11
R8 17 18 1.92e-1
C9 18 19 2.68e-7
L9 18 19 1.31e-11
R9 18 19 3.29e-2
C10 19 20 1.21e-7
L10 19 20 1.84e-11
R10 19 20 5.42e-2
C11 20 21 2.23e-7
L11 20 21 5.08e-12
R11 20 21 1.87e-2
C12 21 port2 7.41e-13
L12 21 port2 4.94e-10
R12 21 port2 724
R100 port1 11 7.35e+9
.ENDS GRM31C5C1H683JA01_DC0V_25degC
