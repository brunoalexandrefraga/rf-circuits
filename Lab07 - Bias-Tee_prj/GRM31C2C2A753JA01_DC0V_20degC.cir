*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH/75000pF/100V
* Murata P/N :GRM31C2C2A753JA01
* Property : C = 75000[pF]
* Data Generated on Jan 10, 2017
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz-6GHz
*   Temperature = 20 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM31C2C2A753JA01_DC0V_20degC port1 port2
C1 port1 11 7.53e-8
L2 11 12 8.65e-11
R3 12 13 3.19e-3
L4 13 14 1.97e-11
R4 13 14 1.31e-1
L5 14 15 1.57e-10
R5 14 15 8.18e-2
L6 15 16 1.54e-10
R6 15 16 3.68e-3
L7 16 17 4.55e-10
R7 16 17 1.02e-3
C8 17 18 4.49e-7
L8 17 18 3.67e-11
R8 17 18 9.39e-2
C9 18 19 9.98e-8
L9 18 19 6.91e-11
R9 18 19 1.42e-1
C10 19 20 9.40e-8
L10 19 20 2.17e-11
R10 19 20 3.53e-2
C11 20 port2 1.10e-12
L11 20 port2 6.20e-10
R11 20 port2 1.07e+3
R100 port1 11 6.67e+9
.ENDS GRM31C2C2A753JA01_DC0V_20degC
