*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G/44000pF/630V
* Murata P/N :KRM55V5C2J443JDL2
* Property : C = 44000[pF]
* Data Generated on Apr 1, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100Hz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KRM55V5C2J443JDL2_DC0V_25degC port1 port2
C1 port1 11 4.27e-8
L2 11 12 4.50e-10
R3 12 13 4.09e-3
C4 13 14 3.52e-4
R4 13 14 9.38
C5 14 15 7.40e-4
R5 14 15 4.71e-1
C6 15 16 8.58e-4
R6 15 16 2.06e-1
C7 16 17 5.49e-4
R7 16 17 4.58e-2
C8 17 18 3.80e-4
R8 17 18 4.62e-3
L9 18 19 1.26e-10
R9 18 19 8.75e-2
L10 19 20 2.53e-10
R10 19 20 5.81e-2
L11 20 21 7.57e-11
R11 20 21 1.50e-3
C12 21 22 8.39e-8
L12 21 22 8.54e-11
R12 21 22 3.39e-2
C13 22 23 8.35e-8
L13 22 23 2.30e-11
R13 22 23 1.86e-1
C14 23 24 1.65e-7
L14 23 24 3.42e-12
R14 23 24 4.78e-2
C15 24 25 3.27e-12
L15 24 25 8.45e-10
R15 24 25 1.35e+3
C16 25 port2 3.30e-11
L16 25 port2 8.07e-11
R16 25 port2 3.35
R100 port1 11 1.00e+10
.ENDS KRM55V5C2J443JDL2_DC0V_25degC
