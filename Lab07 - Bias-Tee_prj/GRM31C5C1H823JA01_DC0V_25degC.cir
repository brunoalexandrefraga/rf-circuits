*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G/82000pF/50V
* Murata P/N :GRM31C5C1H823JA01
* Property : C = 82000[pF]
* Data Generated on Jan 10, 2017
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM31C5C1H823JA01_DC0V_25degC port1 port2
C1 port1 11 8.17e-8
L2 11 12 1.60e-10
R3 12 13 3.14e-3
L4 13 14 1.92e-10
R4 13 14 1.47e-1
L5 14 15 1.69e-10
R5 14 15 2.87e-3
C6 15 16 2.23e-7
L6 15 16 9.69e-11
R6 15 16 2.18e-1
C7 16 17 1.26e-7
L7 16 17 8.03e-11
R7 16 17 1.95e-1
C8 17 18 2.26e-7
L8 17 18 2.31e-11
R8 17 18 6.90e-2
C9 18 19 1.30e-7
L9 18 19 2.61e-11
R9 18 19 8.41e-2
C10 19 port2 1.33e-12
L10 19 port2 2.96e-10
R10 19 port2 200
R100 port1 11 6.10e+9
.ENDS GRM31C5C1H823JA01_DC0V_25degC
