*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :1005M(0402)/X7R/56000pF/16V
* Murata P/N :GRM155R71C563KA88
* Property : C = 56000[pF]
* Data Generated on Feb 1, 2022
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100Hz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM155R71C563KA88_DC0V_25degC port1 port2
C1 port1 11 5.39e-8
L2 11 12 1.54e-10
R3 12 13 2.71e-2
C4 13 14 6.93e-6
R4 13 14 533
C5 14 15 1.11e-5
R5 14 15 75.3
C6 15 16 7.15e-6
R6 15 16 24.9
C7 16 17 6.79e-6
R7 16 17 2.86
C8 17 18 5.82e-6
R8 17 18 5.09e-1
C9 18 19 6.03e-6
R9 18 19 7.32e-2
C10 19 20 3.42e-6
R10 19 20 2.76e-2
L11 20 21 6.63e-11
R11 20 21 1.25e-1
L12 21 22 1.44e-11
R12 21 22 1.19e-1
C13 22 23 2.70e-8
L13 22 23 6.17e-11
R13 22 23 3.61e-2
C14 23 port2 2.16e-12
L14 23 port2 1.39e-10
R14 23 port2 24.8
R100 port1 11 8.93e+9
.ENDS GRM155R71C563KA88_DC0V_25degC
