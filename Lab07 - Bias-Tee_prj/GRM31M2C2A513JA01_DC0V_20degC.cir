*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/CH/51000pF/100V
* Murata P/N :GRM31M2C2A513JA01
* Property : C = 51000[pF]
* Data Generated on Jan 10, 2017
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz-6GHz
*   Temperature = 20 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM31M2C2A513JA01_DC0V_20degC port1 port2
C1 port1 11 5.16e-8
L2 11 12 4.36e-11
R3 12 13 2.52e-3
L4 13 14 1.19e-10
R4 13 14 1.11e-1
L5 14 15 1.75e-11
R5 14 15 8.71e-2
L6 15 16 8.16e-11
R6 15 16 3.69e-3
L7 16 17 5.78e-10
R7 16 17 1.69e-3
C8 17 18 1.52e-7
L8 17 18 6.85e-11
R8 17 18 1.45e-1
C9 18 19 6.18e-8
L9 18 19 7.15e-11
R9 18 19 2.07e-1
C10 19 20 2.53e-8
L10 19 20 5.60e-11
R10 19 20 6.91e-2
C11 20 port2 9.94e-13
L11 20 port2 4.40e-10
R11 20 port2 645
R100 port1 11 9.80e+9
.ENDS GRM31M2C2A513JA01_DC0V_20degC
