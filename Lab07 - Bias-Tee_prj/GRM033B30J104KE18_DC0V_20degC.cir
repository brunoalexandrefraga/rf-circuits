*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0603M(0201)/B/0.1uF/6.3V
* Murata P/N :GRM033B30J104KE18
* Property : C = 0.1[uF]
* Data Generated on Apr 2, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100Hz-6GHz
*   Temperature = 20 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM033B30J104KE18_DC0V_20degC port1 port2
C1 port1 11 8.23e-8
L2 11 12 1.46e-10
R3 12 13 2.62e-2
C4 13 14 4.66e-6
R4 13 14 420
C5 14 15 6.29e-6
R5 14 15 59.3
C6 15 16 7.06e-6
R6 15 16 7.29
C7 16 17 6.14e-6
R7 16 17 1.16
C8 17 18 5.27e-6
R8 17 18 2.15e-1
C9 18 19 3.09e-6
R9 18 19 5.24e-2
L10 19 20 3.71e-11
R10 19 20 6.39
L11 20 21 1.61e-11
R11 20 21 1.75e-1
L12 21 22 4.70e-11
R12 21 22 7.48e-2
C13 22 port2 7.22e-8
L13 22 port2 2.88e-11
R13 22 port2 1.61e-2
R100 port1 11 5.00e+8
.ENDS GRM033B30J104KE18_DC0V_20degC
