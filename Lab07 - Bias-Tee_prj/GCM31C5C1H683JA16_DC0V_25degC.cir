*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G/68000pF/50V
* Murata P/N :GCM31C5C1H683JA16
* Property : C = 68000[pF]
* Data Generated on Jan 10, 2018
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GCM31C5C1H683JA16_DC0V_25degC port1 port2
C1 port1 11 6.79e-8
L2 11 12 1.19e-11
R3 12 13 3.10e-3
L4 13 14 1.13e-11
R4 13 14 5.12e-1
L5 14 15 1.59e-10
R5 14 15 1.32e-1
L6 15 16 1.23e-10
R6 15 16 3.30e-3
L7 16 17 2.74e-10
R7 16 17 8.10e-4
C8 17 18 1.67e-7
L8 17 18 1.01e-10
R8 17 18 1.79e-1
C9 18 19 1.05e-7
L9 18 19 7.21e-11
R9 18 19 1.94e-1
C10 19 20 2.68e-7
L10 19 20 1.47e-11
R10 19 20 3.76e-2
C11 20 21 8.31e-8
L11 20 21 2.89e-11
R11 20 21 6.55e-2
C12 21 port2 7.67e-13
L12 21 port2 5.50e-10
R12 21 port2 1.05e+3
R100 port1 11 1.47e+10
.ENDS GCM31C5C1H683JA16_DC0V_25degC
