*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :5750M(2220)/C0G/54000pF/630V
* Murata P/N :KCM55V5C2J543JDL2
* Property : C = 54000[pF]
* Data Generated on Apr 1, 2024
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100Hz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT KCM55V5C2J543JDL2_DC0V_25degC port1 port2
C1 port1 11 5.35e-8
L2 11 12 1.45e-17
R3 12 13 3.82e-3
C4 13 14 1.25e-3
R4 13 14 1.41
C5 14 15 6.00e-3
R5 14 15 8.25e-1
C6 15 16 5.65e-4
R6 15 16 3.43e-1
C7 16 17 5.72e-4
R7 16 17 7.15e-2
C8 17 18 4.39e-4
R8 17 18 4.90e-3
L9 18 19 4.59e-10
R9 18 19 23.4
L10 19 20 4.64e-10
R10 19 20 1.40e-1
L11 20 21 3.39e-10
R11 20 21 1.05e-1
C12 21 22 9.46e-11
L12 21 22 3.97e-11
R12 21 22 12.6
C13 22 23 3.77e-12
L13 22 23 7.80e-10
R13 22 23 1.20e+4
C14 23 port2 2.87e-12
L14 23 port2 1.08e-9
R14 23 port2 705
R100 port1 11 1.00e+10
.ENDS KCM55V5C2J543JDL2_DC0V_25degC
