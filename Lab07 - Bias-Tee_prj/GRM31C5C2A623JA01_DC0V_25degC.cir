*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :3216M(1206)/C0G/62000pF/100V
* Murata P/N :GRM31C5C2A623JA01
* Property : C = 62000[pF]
* Data Generated on Jan 10, 2017
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 1MHz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM31C5C2A623JA01_DC0V_25degC port1 port2
C1 port1 11 6.26e-8
L2 11 12 9.19e-11
R3 12 13 3.85e-3
L4 13 14 1.14e-11
R4 13 14 9.69e-2
L5 14 15 1.22e-10
R5 14 15 8.99e-2
L6 15 16 1.27e-10
R6 15 16 4.95e-3
L7 16 17 5.63e-10
R7 16 17 1.43e-3
C8 17 18 3.20e-7
L8 17 18 3.98e-11
R8 17 18 8.46e-2
C9 18 19 7.78e-8
L9 18 19 6.54e-11
R9 18 19 1.32e-1
C10 19 20 3.62e-8
L10 19 20 3.44e-11
R10 19 20 3.40e-2
C11 20 port2 1.07e-12
L11 20 port2 6.98e-10
R11 20 port2 781
R100 port1 11 8.06e+9
.ENDS GRM31C5C2A623JA01_DC0V_25degC
