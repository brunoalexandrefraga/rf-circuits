*----------------------------------------------------------------------
* SPICE Model generated by Murata Manufacturing Co., Ltd.
* Copyright(C) Murata Manufacturing Co., Ltd.
* Description :0402M(01005)/X7R/150pF/16V
* Murata P/N :GRM022R71C151KE14
* Property : C = 150[pF]
* Data Generated on Nov 6, 2018
*----------------------------------------------------------------------
* Applicable Conditions:
*   Frequency Range = 100Hz-6GHz
*   Temperature = 25 degC
*   DC Bias Voltage = 0V
*   Small Signal Operation
*----------------------------------------------------------------------
.SUBCKT GRM022R71C151KE14_DC0V_25degC port1 port2
C1 port1 11 1.51e-10
L2 11 12 1.78e-10
R3 12 13 7.08e-1
C4 13 14 1.21e-8
R4 13 14 1.18e+5
C5 14 15 4.32e-8
R5 14 15 7.47e+3
C6 15 16 2.87e-8
R6 15 16 1.83e+3
C7 16 17 2.13e-8
R7 16 17 341
C8 17 18 1.29e-8
R8 17 18 46.2
C9 18 19 8.92e-9
R9 18 19 6.11
C10 19 20 6.19e-9
R10 19 20 8.56e-1
C11 20 21 1.14e-9
R11 20 21 5.53e-1
C12 21 port2 3.11e-11
L12 21 port2 1.21e-11
R12 21 port2 8.42e-1
R100 port1 11 2.00e+9
.ENDS GRM022R71C151KE14_DC0V_25degC
